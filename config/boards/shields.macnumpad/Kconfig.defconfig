## config/boards/shields.macnumpad/Kconfig.defconfig
```kconfig
	if SHIELD_MACNUMPAD
	
	config ZMK_KEYBOARD_NAME
		default "macnumpad"
	
	end if
```
